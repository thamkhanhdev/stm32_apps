# Keil uVision project CLOCK_F205.uvprojx, settings and files
target CLOCK_F205 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205RCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CLOCK_F205 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=16000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32F205xx
  c include: ../Inc;      ../Drivers/STM32F2xx_HAL_Driver/Inc;      ../Drivers/CMSIS/Device/ST/STM32F2xx/Include;      ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Application/User
    ../Src/: main.c stm32f2xx_it.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_gpio.c stm32f2xx_ll_rcc.c stm32f2xx_ll_utils.c stm32f2xx_ll_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
software components: CMSIS:CORE 4.3.0
